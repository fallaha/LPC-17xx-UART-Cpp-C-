# Keil uVision project UART.uvproj, settings and files
target LPC17xx (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UART +hex
  AfterMake: fromelf --bin ".\OBJ\UART.axf" --output ".\UART.bin"
  c flags: Optim=1
  c misc: --cpp11
  asm define: NO_CRP
  memory RVCT4: ROM 0x2000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup
    ./: startup_LPC17xx.s system_LPC17xx.c
  group source
    ./: main.cpp
    ./AF_LIB/: UART.cpp AF_CPU.cpp
